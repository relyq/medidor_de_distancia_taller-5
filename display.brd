File: display.brd (EAGLE design)
At the start: 32.9 x 30.3 mm, 2 parts

Commit message: ahora si funciona
Parts:
- moved J1 63.1 mm to (5.08, 2.54)
- moved D1 63.1 mm to (16.5, 17.8)
